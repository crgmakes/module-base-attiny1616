File: pcb/interfaces.kicad_sch (KiCad schematic)
At the start: 12 parts

Commit message: Clean up and fixed attributes
Parts:
- D1: MN Nexperia -> TECH PUBLIC; MPN PESD5V5C1BLYL -> TPSP3022-01ETG
